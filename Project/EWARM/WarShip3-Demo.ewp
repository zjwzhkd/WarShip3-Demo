# IAR project WarShip3-Demo.ewp, settings and files
configuration SRAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\..\Source\CPU\cmsis\Include; ..\..\Source\CPU\common\include; ..\..\Source\CPU\stm32f1\include; ..\..\Source\CPU\stm32f1\config; ..\..\Source\CPU\stm32f1\device\include; ..\..\Source\CPU\stm32f1\fwlib\inc; ..\..\Source\Scheduler\include; ..\..\Source\Scheduler\config; ..\..\Source\Board\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WarShip3-Demo.srec
  ILINK.IlinkOutputFile: WarShip3-Demo.out
  ILINK.IlinkIcfFile: stm32f10x_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Board
    ../../Source/Board/: bsp.c bsp_debug.c
  group CPU
    ../../Source/CPU/stm32f1/: cpu.c cpu_port.c cpu_tick.c
  group CPU/common
    ../../Source/CPU/common/: cpulib_fifo.c cpulib_heap.c cpulib_list.c
  group CPU/device
    ../../Source/CPU/stm32f1/device/startup/iar/: startup_stm32f10x_hd.s
    ../../Source/CPU/stm32f1/device/: stm32f10x_assert.c stm32f10x_it.c system_stm32f10x.c
  group CPU/fwlib
    ../../Source/CPU/stm32f1/fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Scheduler/framework
    ../../Source/Scheduler/framework/: sched_alarm.c sched_api.c sched_core.c sched_daemon.c sched_event_queue.c sched_event_table.c sched_fsm.c sched_task.c
  group Scheduler/internal
    ../../Source/Scheduler/internal/: sched_list.c sched_priotbl.c sched_queue.c
  group Scheduler/portable
    ../../Source/Scheduler/portable/: sched_heap_1.c sched_port.c
  group User
    ../../Source/User/: main.c
